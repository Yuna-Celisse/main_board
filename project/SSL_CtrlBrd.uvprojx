# Keil uVision project SSL_CtrlBrd.uvprojx, settings and files
target SSL_CtrlBrd (6220000::V6.22::ARMCLANG)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SSL_CtrlBrd +hex
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARM_MATH_CM4,__FPU_PRESENT,USE_USB_OTG_FS
  c misc: -Wno-armcc-pragma-anon-unions -Wno-nonportable-include-path -Wno-unused-parameter -Wno-literal-conversion -Wno-sign-compare -Wno-pointer-sign -Wno-empty-body -Wno-char-subscripts -Wno-ignored-attributes -Wno-missing-field-initializers -Wno-tautological-constant-out-of-range-compare -Wno-unknown-pragmas
  c include: ..\inc;..\inc\usb_user;..\lib\CMSIS\inc;..\lib\inc;..\lib\usb_device_lib\Class\cdc\inc;..\lib\usb_device_lib\Core\inc;..\lib\usb_host_lib\Class\HID\inc;..\lib\usb_host_lib\Core\inc;..\lib\usb_otg_driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../src/: action.c comm.c Cpuid_des.c error_event.c factory.c gpio.c Hm_bluetooth.c i2c.c init.c main.c misc.c motor.c MPU6050_driver.c nrf24l01.c nrf24l01_drv.c packet.c param.c pid.c robot.c stm32f4xx_it.c system_stm32f4xx.c timer.c typedef.c Usart_ble.c startup_stm32f4xx.s
    ../src/usb_user/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c usbh_usr.c
  group lib
    ../lib/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_misc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group cmsis
    ../lib/CMSIS/: arm_cortexM4lf_math.lib
  group usb_host
    ../lib/usb_host_lib/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../lib/usb_otg_driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../lib/usb_host_lib/Class/HID/src/: usbh_hid_core.c Usbh_hid_joystick.c usbh_hid_keybd.c usbh_hid_mouse.c
  group usb_device
    ../lib/usb_device_lib/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../lib/usb_otg_driver/src/: usb_dcd.c usb_dcd_int.c
    ../lib/usb_device_lib/Class/cdc/src/: usbd_cdc_core.c usbd_cdc_if_template.c
